# Keil uVision project GreenhouseControl.uvprojx, settings and files
target Target 1 (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GreenhouseControl +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Public;.\APP\dht11;.\APP\lsens;.\APP\led;.\APP\beep;.\APP\key;.\APP\hc05;.\APP\greenhouse_control;.\APP\tftlcd
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.c stm32f10x_it.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_iwdg.c stm32f10x_wwdg.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_rtc.c stm32f10x_can.c stm32f10x_fsmc.c stm32f10x_spi.c stm32f10x_flash.c
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f10x.c core_cm3.c
  group APP
    ./APP/dht11/: dht11.c
    ./APP/lsens/: lsens.c
    ./APP/led/: led.c
    ./APP/beep/: beep.c
    ./APP/key/: key.c
    ./APP/hc05/: hc05.c
    ./APP/greenhouse_control/: greenhouse_control.c greenhouse_display.c
    ./APP/tftlcd/: tftlcd.c
    ./APP/: missing_functions_stub.c
    ./APP/data_logger/: data_logger.c
    ./APP/fan_pwm/: fan_pwm.c
    ./APP/ws2812/: ws2812.c
  group Public
    ./Public/: system.c SysTick.c usart.c usart3.c
